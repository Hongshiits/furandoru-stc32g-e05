# Keil uVision project MUX_EMF.uvproj, settings and files
target MUX_EMF (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: MUX_EMF +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Sources\inc
  group AiCube
    ./Sources/: main.c port.c clock.c uart.c adc.c
